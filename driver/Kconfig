## driver/Kconfig
```kconfig
menu "MEMGUARD"
config MEMGUARD
	tristate "the driver is memguard"
	default Y
endmenu
```
